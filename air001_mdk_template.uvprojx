# Keil uVision project air001_mdk_template.uvprojx, settings and files
target air001_mdk_template (6120000::V6.12::.\ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: air001_mdk_template +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AIR001_DEV
  c include: .\luatos-soc-air001\Libraries\CMSIS\Include;.\luatos-soc-air001\Libraries\CMSIS\Device\AIR001xx\Include;.\luatos-soc-air001\Libraries\AIR001xx_HAL_Driver\Inc;.\luatos-soc-air001\Libraries\AIR001xx_HAL_Driver\Inc\Legacy;.\Sources\app
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS/startup
    ./luatos-soc-air001/Libraries/CMSIS/Device/AIR001xx/Source/: system_air001xx.c
    ./luatos-soc-air001/Libraries/CMSIS/Device/AIR001xx/Source/arm/: startup_air001_dev.s
  group CMSIS/HAL_Driver
    ./luatos-soc-air001/Libraries/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_adc.c air001xx_hal_adc_ex.c air001xx_hal_can.c air001xx_hal_cec.c air001xx_hal_comp.c air001xx_hal_cortex.c air001xx_hal_crc.c air001xx_hal_crc_ex.c air001xx_hal_dac.c air001xx_hal_dac_ex.c air001xx_hal_dma.c air001xx_hal_exti.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_i2c.c air001xx_hal_i2c_ex.c air001xx_hal_i2s.c air001xx_hal_irda.c air001xx_hal_iwdg.c air001xx_hal_led.c air001xx_hal_lptim.c air001xx_hal_pcd.c air001xx_hal_pcd_ex.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_rtc.c air001xx_hal_rtc_ex.c air001xx_hal_smartcard.c air001xx_hal_smartcard_ex.c air001xx_hal_smbus.c air001xx_hal_spi.c air001xx_hal_spi_ex.c air001xx_hal_tim.c air001xx_hal_tim_ex.c air001xx_hal_tsc.c air001xx_hal_uart.c air001xx_hal_usart.c air001xx_hal_wwdg.c
  group app
    ./Sources/app/: main.c air001xx_it.c
software components: CMSIS:CORE 5.6.0
